# Keil uVision project ble_app_lbs_central.uvprojx, settings and files
target nrf51822_xxaa_s130 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_InternalDeviceFamilyPack.8.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ble_app_lbs_central +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10028 SOFTDEVICE_PRESENT S130 CENTRAL
  c misc: --c99
  c include: ..\config;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\libraries\button;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\softdevice\s130\headers;..\..\..\..\..\components\ble\common;..\..\..\..\bsp;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\components\ble\ble_debug_assert_handler;..\..\..\..\..\components\ble\ble_error_log;..\..\..\..\..\components\drivers_nrf\pstorage;..\..\;..\..\..\..\..\components\drivers_nrf\ble_flash;..\..\;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\ble\ble_db_discovery\;..\..\..\..\..\components\ble\device_manager;..\..\..\..\..\components\ble\ble_db_discovery;..\..\;..\..\..\..\..\components\ble\device_manager\config;..\..\;..\..\..\..\..\components\libraries\trace
  memory RVCT4: ROM 0x1c000 size 0x24000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Startup Code
    ../../../../../components/toolchain/: system_nrf51.c
    ../../../../../components/toolchain/arm/: arm_startup_nrf51.s
  group Source Code
    ../../: main.c client_handling.c
  group Services
    ../../../../../components/ble/device_manager/: device_manager_central.c
    ../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../: ble_lbs.c
    ../../../../../components/ble/common/: ble_srv_common.c
  group Libraries
    ../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
    ../../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../components/libraries/util/: app_error.c
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/pstorage/: pstorage.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
